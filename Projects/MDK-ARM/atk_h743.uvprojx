# Keil uVision project atk_h743.uvprojx, settings and files
target TOUCH (6240000::V6.24::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h743 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H743xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Middlewares;..\..\Middlewares\FatFs;..\..\User;..\..\App;..\..\Middlewares\FreeRTOS-Kernel-main\include;..\..\Middlewares\FreeRTOS-Kernel-main\portable\GCC\ARM_CM7\r0p1;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c FreeRTOSConfig.h
  group App
    ../../App/: app_input.c app_input.h app_ui.c app_ui.h app_runtime.c app_runtime.h app_monitor.c app_monitor.h app_storage.c app_storage.h app_files.c app_files.h app_draw.c app_draw.h app_logs.c app_logs.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/SDMMC/: sdmmc_sdcard.c sdmmc_sdcard.h
  group FatFs
    ../../Middlewares/FatFs/: ff.c diskio.c ff.h ffconf.h diskio.h integer.h
  group Readme
    ../../: readme.txt
  group FreeRTOS/Kernel
    ../../Middlewares/FreeRTOS-Kernel-main/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../Middlewares/FreeRTOS-Kernel-main/portable/GCC/ARM_CM7/r0p1/: port.c
    ../../Middlewares/FreeRTOS-Kernel-main/portable/MemMang/: heap_4.c
